Commit message: Update polaris.urdf

File: models/polaris.urdf (robot description, URDF)
Before this commit: robot polaris_ranger_ev, 8 links, 7 joints
Links:
- link polaris_ranger_ev__chassis: geometry collision box size=0.05 1.2 0.25; collision box size=0.05 1.2 0.25
